# IAR project invensense_imu_stm32_project.ewp, settings and files
configuration invensense_imu_stm32_project (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; MPU9250; EMPL_TARGET_STM32F4
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Src; ..\Src\imu_driver\imu_driver_uart; ..\Src\imu_driver\imu_driver_int; ..\Src\imu_driver\imu_drivert_core\core\driver\eMPL; ..\Src\imu_driver\imu_drivert_core\core\driver\include; ..\Src\imu_driver\imu_drivert_core\core\driver\stm32L; ..\Src\imu_driver\imu_drivert_core\core\eMPL-hal; ..\Src\imu_driver\imu_drivert_core\core\mllite; ..\Src\imu_driver\imu_drivert_core\core\mpl; ..\Src\imu_driver\imu_drivert_core\DeviceSupport; ..\Src\imu_driver\imu_drivert_core; ..\Src\imu_driver\imu_driver_i2c
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: invensense_imu_stm32_project.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\Src\imu_driver\mpl libraries\libmpllib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: app_util.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/imu_driver/imu_driver_core
    ../Src/imu_driver/imu_drivert_core/: dGyro.c
  group Application/User/imu_driver/imu_driver_core/core/driver/eMPL
    ../Src/imu_driver/imu_drivert_core/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Application/User/imu_driver/imu_driver_core/core/driver/stm32L
    ../Src/imu_driver/imu_drivert_core/core/driver/stm32L/: log_stm32.c
  group Application/User/imu_driver/imu_driver_core/core/eMPL-hal
    ../Src/imu_driver/imu_drivert_core/core/eMPL-hal/: eMPL_outputs.c
  group Application/User/imu_driver/imu_driver_core/core/mllite
    ../Src/imu_driver/imu_drivert_core/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group Application/User/imu_driver/imu_driver_core/DeviceSupport
    ../Src/imu_driver/imu_drivert_core/DeviceSupport/: board-st_discovery.c
  group Application/User/imu_driver/imu_driver_i2c
    ../Src/imu_driver/imu_driver_i2c/: imu_driver_i2c.c
  group Application/User/imu_driver/imu_driver_int
    ../Src/imu_driver/imu_driver_int/: imu_driver_int.c
  group Application/User/imu_driver/imu_driver_uart
    ../Src/imu_driver/imu_driver_uart/: imu_driver_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
